# Keil uVision project KEY.uvprojx, settings and files
target KEY (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\CORE;..\USER;..\OBJ;..\SYSTEM\delay;..\HALLIB\STM32F1xx_HAL_Driver\Inc;..\SYSTEM\SYS_INT;..\HARDWARE\delay;..\HARDWARE\Rs485;..\HARDWARE\Usart;..\HARDWARE\WiFi;..\HARDWARE\TIMER;..\HARDWARE\ConnectZL;..\HARDWARE;..\HARDWARE\LED;..\uCOS-II\Config;..\uCOS-II\Ports;..\uCOS-II\Source
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f1xx_it.c system_stm32f1xx.c stm32f1xx_hal_msp.c
  group CORE
    ../CORE/: core_cm3.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f103xe.s
  group HALLIB
    ../HALLIB/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group HARDWARE
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/Rs485/: Rs485.c Rs485.h
    ../HARDWARE/Usart/: Usart.c Usart.h
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/WiFi/: WiFi.c WiFi.h
    ../HARDWARE/ConnectZL/: ConnectZL.c ConnectZL.h
    ../HARDWARE/: slip.c slip.h
    ../HARDWARE/LED/: led.c led.h
  group uCOSII/Config
    ../uCOS-II/Config/: includes.h os_cfg.h
  group uCOSII/Ports
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOSII/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOSII/ReadMe
    ../uCOS-II/ReadMe/: ReadMe.txt
